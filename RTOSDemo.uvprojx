# Keil uVision project RTOSDemo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOSDemo +hex
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102
  c include: .\Common\include;.\Common\Minimal;.\STM32F10xFWLib\inc;.\FreeRTOS-Kernel\include;.\FreeRTOS-Kernel\portable\RVDS\ARM_CM3;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group firmware
    ./: STM32F10x.s
    ./STM32F10xFWLib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c lcd.c cortexm3_macro_rvds.s core_cm3.c
  group Demo Files
    ./ParTest/: ParTest.c
    ./serial/: serial.c
    ./: timertest.c spi_flash.c led.c main.c
  group FreeRTOS_core
    ./FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group demo_deps
    ./Common/Minimal/: BlockQ.c blocktim.c comtest.c death.c flash.c integer.c PollQ.c semtest.c
